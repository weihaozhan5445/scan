# Keil uVision project scan.uvprojx, settings and files
target scan (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8004000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: scan +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Application/Include;../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/include;../FreeRTOS/portable;../FreeRTOS/source;../FreeRTOS/portable/RVDS/ARM_CM3;../FreeRTOS;../BSP/Sensors;../BSP/Actuators;../BSP/Display;../BSP/Storage;../Middleware/Network;../Common;../legacy/rtos_task
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Freertos/source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Freertos/portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: portmacro.h port.c
  group Freertos/include
    ../FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h
  group BSP
    ../BSP/Sensors/: BH1750.c BH1750.h mq2.c MQ_2.h Dht11.c Dht11.h
    ../BSP/Actuators/: Buzzer.c Buzzer.h
    ../BSP/Display/: OLED.c OLED.h OLED_DATA.c OLED_DATA.h
    ../BSP/Storage/: Int_w24c02.c Int_w24c02.h Int_w25q32.c Int_w25q32.h
  group Application
    ../Application/Tasks/: environment_tasks.c
    ../Application/Include/: app_tasks.h display_service.h environment_data.h iap.h app_hooks.h ota_image.h
    ../Application/Services/: display_service.c environment_service.c firmware_update_service.c iap.c app_hooks.c
    ../legacy/rtos_task/: APP_update.h
  group Common
    ../Common/: com_debug.c com_debug.h delay.c delay.h crc32.c crc32.h
  group Middleware/Network
    ../Middleware/Network/: ESP8266.c ESP8266.h ota_task.h
    ../Application/Services/: ota_command_service.c
software components: CMSIS:CORE 4.3.0
