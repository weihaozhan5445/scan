# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F103xB
  c include: ../Bootloader;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Bootloader/Startup
    ../Bootloader/: startup_stm32f103xb.s
  group Bootloader/Core
    ../Bootloader/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group Bootloader/Drivers
    ../Bootloader/: bl_config.h bl_crc32.c bl_delay.c bl_flash.c bl_i2c.c bl_iap.c bl_spi.c bl_uart.c bl_w24c02.c bl_w25q32.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h stm32f103xb.h
    ../Drivers/CMSIS/Include/: core_cm3.h
software components: CMSIS:CORE 4.3.0
